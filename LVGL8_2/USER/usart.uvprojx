# Keil uVision project usart.uvprojx, settings and files
target usart (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: usart +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F10X_FWLib\inc;..\CORE;..\HARDWARE;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\SPI;..\HARDWARE\TIMER;..\HARDWARE\TOUCH;..\HARDWARE\W25QXX;..\Middleware\LVGL\GUI;..\Middleware\LVGL\GUI\lvgl;..\Middleware\LVGL\GUI\lvgl\examples\porting;..\Middleware\LVGL\GUI\lvgl\src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ../CORE/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c delay.h
    ../SYSTEM/sys/: sys.c sys.h
  group USER
    ./: main.c stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../STM32F10X_FWLib/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ../STM32F10X_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ./: iwdg.c iwdg.h key.c key.h led.c led.h wwdg.c wwdg.h
    ../HARDWARE/24CXX/: 24cxx.c 24cxx.h
    ../HARDWARE/IIC/: myiic.c myiic.h
    ../HARDWARE/LCD/: font.h lcd.c lcd.h
    ../HARDWARE/SPI/: spi.c spi.h
    ../HARDWARE/TIMER/: timer.c timer.h
    ../HARDWARE/TOUCH/: ctiic.c ctiic.h ft5206.c ft5206.h gt9147.c gt9147.h ott2001a.c ott2001a.h touch.c touch.h
    ../HARDWARE/W25QXX/: w25qxx.c w25qxx.h
  group Middleware/LVGL/example/porting
    ../Middleware/LVGL/GUI/lvgl/examples/porting/: lv_port_disp_template.c lv_port_disp_template.h lv_port_indev_template.c lv_port_indev_template.h
  group Middleware/LVGL/src/core
    ../Middleware/LVGL/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group Middleware/LVGL/src/draw
    ../Middleware/LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Middleware/LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
  group Middleware/LVGL/src/extra
    ../Middleware/LVGL/GUI/lvgl/src/extra/: lv_extra.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/win/: lv_win.c
  group Middleware/LVGL/src/font
    ../Middleware/LVGL/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group Middleware/LVGL/src/gpu
    ../Middleware/LVGL/GUI/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../Middleware/LVGL/GUI/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
  group Middleware/LVGL/src/hal
    ../Middleware/LVGL/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group Middleware/LVGL/src/misc
    ../Middleware/LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group Middleware/LVGL/src/widgets
    ../Middleware/LVGL/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c

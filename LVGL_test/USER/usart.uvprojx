# Keil uVision project usart.uvprojx, settings and files
target usart (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: usart +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F10X_FWLib\inc;..\CORE;..\HARDWARE;..\Middlewares\LVGL\GUI;..\Middlewares\LVGL\GUI\lvgl;..\Middlewares\LVGL\GUI\lvgl\examples\porting;..\Middlewares\LVGL\GUI\lvgl\src;..\HARDWARE\LCD;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\SPI;..\HARDWARE\W25QXX
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ../CORE/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c delay.h
    ../SYSTEM/sys/: sys.c sys.h
  group USER
    ./: main.c stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../STM32F10X_FWLib/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ../STM32F10X_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/: usart.c
    ./: iwdg.c iwdg.h key.c key.h led.c led.h wwdg.c wwdg.h
    ../HARDWARE/TOUCH/: ctiic.c ctiic.h ft5206.c ft5206.h gt9147.c gt9147.h ott2001a.c ott2001a.h touch.c touch.h
    ../HARDWARE/TIMER/: timer.c timer.h
    ../HARDWARE/LCD/: font.h lcd.c lcd.h
    ../HARDWARE/24CXX/: 24cxx.c 24cxx.h
    ../HARDWARE/IIC/: myiic.c myiic.h
    ../HARDWARE/SPI/: spi.c spi.h
    ../HARDWARE/W25QXX/: w25qxx.c w25qxx.h
  group MiddleWare/lvgl/example/porting
    ../Middlewares/LVGL/GUI/lvgl/examples/porting/: lv_port_disp_template.c lv_port_disp_template.h lv_port_indev_template.c lv_port_indev_template.h
  group MiddleWare/lvgl/src/core
    ../Middlewares/LVGL/GUI/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_global.h lv_group.h lv_group_private.h lv_obj.h lv_obj_class.h lv_obj_class_private.h lv_obj_draw.h lv_obj_draw_private.h lv_obj_event.h lv_obj_event_private.h lv_obj_pos.h lv_obj_private.h lv_obj_property.h lv_obj_scroll.h lv_obj_scroll_private.h lv_obj_style.h lv_obj_style_gen.h lv_obj_style_private.h lv_obj_tree.h lv_refr.h lv_refr_private.h
    ../Middlewares/LVGL/GUI/lvgl/src/: lv_api_map_v8.h lv_api_map_v9_0.h lv_api_map_v9_1.h lv_conf_internal.h lv_conf_kconfig.h lv_init.c lv_init.h lvgl.h lvgl_private.h
  group MiddleWare/lvgl/src/draw
    ../Middlewares/LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c
    ../Middlewares/LVGL/GUI/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb888.c
    ../Middlewares/LVGL/GUI/lvgl/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
    ../Middlewares/LVGL/GUI/lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
  group MiddleWare/lvgl/src/font
    ../Middlewares/LVGL/GUI/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_14_cjk.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group MiddleWare/lvgl/src/gpu
    ../Middlewares/LVGL/GUI/lvgl/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    ../Middlewares/LVGL/GUI/lvgl/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
    ../Middlewares/LVGL/GUI/lvgl/src/draw/nxp/vglite/: lv_draw_buf_vglite.c lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_border.c lv_draw_vglite_fill.c lv_draw_vglite_img.c lv_draw_vglite_label.c lv_draw_vglite_layer.c lv_draw_vglite_line.c lv_draw_vglite_triangle.c lv_vglite_buf.c lv_vglite_matrix.c lv_vglite_path.c lv_vglite_utils.c
  group MiddleWare/lvgl/src/misc
    ../Middlewares/LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_utils.c
    ../Middlewares/LVGL/GUI/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c lv_cache_lru_rb.c lv_image_cache.c lv_image_header_cache.c
  group MiddleWare/lvgl/src/widgets
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/animimage/: lv_animimage.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/arc/: lv_arc.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/bar/: lv_bar.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/button/: lv_button.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/canvas/: lv_canvas.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/chart/: lv_chart.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/image/: lv_image.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/label/: lv_label.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/led/: lv_led.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/list/: lv_list.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/line/: lv_line.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/lottie/: lv_lottie.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/menu/: lv_menu.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/property/: lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_style_properties.c lv_textarea_properties.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/roller/: lv_roller.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/scale/: lv_scale.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/slider/: lv_slider.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/span/: lv_span.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/spinner/: lv_spinner.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/switch/: lv_switch.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/table/: lv_table.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/tabview/: lv_tabview.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/textarea/: lv_textarea.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/tileview/: lv_tileview.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/win/: lv_win.c
  group MiddleWare/lvgl/src/display
    ../Middlewares/LVGL/GUI/lvgl/src/display/: lv_display.c lv_display.h lv_display_private.h
  group MiddleWare/lvgl/src/drivers
    ../Middlewares/LVGL/GUI/lvgl/src/drivers/display/drm/: lv_linux_drm.c lv_linux_drm.h
    ../Middlewares/LVGL/GUI/lvgl/src/drivers/display/fb/: lv_linux_fbdev.c lv_linux_fbdev.h
    ../Middlewares/LVGL/GUI/lvgl/src/drivers/display/ili9341/: lv_ili9341.c lv_ili9341.h
    ../Middlewares/LVGL/GUI/lvgl/src/drivers/display/lcd/: lv_lcd_generic_mipi.c lv_lcd_generic_mipi.h
    ../Middlewares/LVGL/GUI/lvgl/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c lv_renesas_glcdc.h
    ../Middlewares/LVGL/GUI/lvgl/src/drivers/display/st7735/: lv_st7735.c lv_st7735.h
    ../Middlewares/LVGL/GUI/lvgl/src/drivers/display/st7789/: lv_st7789.c lv_st7789.h
    ../Middlewares/LVGL/GUI/lvgl/src/drivers/display/st7796/: lv_st7796.c lv_st7796.h
    ../Middlewares/LVGL/GUI/lvgl/src/drivers/display/tft_espi/: lv_tft_espi.cpp lv_tft_espi.h
  group MiddleWare/lvgl/src/layouts
    ../Middlewares/LVGL/GUI/lvgl/src/layouts/flex/: lv_flex.c lv_flex.h
    ../Middlewares/LVGL/GUI/lvgl/src/layouts/grid/: lv_grid.c lv_grid.h
    ../Middlewares/LVGL/GUI/lvgl/src/layouts/: lv_layout.c lv_layout.h lv_layout_private.h
  group MiddleWare/lvgl/src/libs
    ../Middlewares/LVGL/GUI/lvgl/src/libs/barcode/: code128.c code128.h lv_barcode.c lv_barcode.h lv_barcode_private.h
    ../Middlewares/LVGL/GUI/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c lv_bin_decoder.h
    ../Middlewares/LVGL/GUI/lvgl/src/libs/bmp/: lv_bmp.c lv_bmp.h
    ../Middlewares/LVGL/GUI/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c lv_ffmpeg.h lv_ffmpeg_private.h
    ../Middlewares/LVGL/GUI/lvgl/src/libs/freetype/: ftmodule.h ftoption.h lv_freetype.c lv_freetype.h lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_freetype_private.h lv_ftsystem.c
    ../Middlewares/LVGL/GUI/lvgl/src/libs/fsdrv/: lv_fs_arduino_esp_littlefs.cpp lv_fs_arduino_sd.cpp lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c lv_fsdrv.h
    ../Middlewares/LVGL/GUI/lvgl/src/libs/gif/: gifdec.c gifdec.h gifdec_mve.h lv_gif.c lv_gif.h lv_gif_private.h
    ../Middlewares/LVGL/GUI/lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c lv_libjpeg_turbo.h
    ../Middlewares/LVGL/GUI/lvgl/src/libs/libpng/: lv_libpng.c lv_libpng.h
    ../Middlewares/LVGL/GUI/lvgl/src/libs/lodepng/: lodepng.c lodepng.h lv_lodepng.c lv_lodepng.h
    ../Middlewares/LVGL/GUI/lvgl/src/libs/lz4/: lz4.c lz4.h
    ../Middlewares/LVGL/GUI/lvgl/src/libs/qrcode/: lv_qrcode.c lv_qrcode.h lv_qrcode_private.h qrcodegen.c qrcodegen.h
    ../Middlewares/LVGL/GUI/lvgl/src/libs/rle/: lv_rle.c lv_rle.h
    ../Middlewares/LVGL/GUI/lvgl/src/libs/rlottie/: lv_rlottie.c lv_rlottie.h lv_rlottie_private.h
    ../Middlewares/LVGL/GUI/lvgl/src/libs/thorvg/: config.h thorvg.h thorvg_capi.h thorvg_lottie.h tvgAccessor.cpp tvgAnimation.cpp tvgAnimation.h tvgArray.h tvgBinaryDesc.h tvgCanvas.cpp tvgCanvas.h tvgCapi.cpp tvgCommon.h tvgCompressor.cpp tvgCompressor.h tvgFill.cpp tvgFill.h tvgFrameModule.h tvgGlCanvas.cpp tvgInitializer.cpp tvgInlist.h tvgIteratorAccessor.h tvgLines.cpp tvgLines.h tvgLoader.cpp tvgLoader.h tvgLoadModule.h tvgLock.h tvgLottieAnimation.cpp tvgLottieBuilder.cpp tvgLottieBuilder.h tvgLottieExpressions.cpp tvgLottieExpressions.h tvgLottieInterpolator.cpp tvgLottieInterpolator.h tvgLottieLoader.cpp tvgLottieLoader.h tvgLottieModel.cpp tvgLottieModel.h tvgLottieParser.cpp tvgLottieParser.h tvgLottieParserHandler.cpp tvgLottieParserHandler.h tvgLottieProperty.h tvgMath.cpp tvgMath.h tvgPaint.cpp tvgPaint.h tvgPicture.cpp tvgPicture.h tvgRawLoader.cpp tvgRawLoader.h tvgRender.cpp tvgRender.h tvgSaveModule.h tvgSaver.cpp tvgScene.cpp tvgScene.h tvgShape.cpp tvgShape.h tvgStr.cpp tvgStr.h tvgSvgCssStyle.cpp tvgSvgCssStyle.h tvgSvgLoader.cpp tvgSvgLoader.h tvgSvgLoaderCommon.h tvgSvgPath.cpp tvgSvgPath.h tvgSvgSceneBuilder.cpp tvgSvgSceneBuilder.h tvgSvgUtil.cpp tvgSvgUtil.h tvgSwCanvas.cpp tvgSwCommon.h tvgSwFill.cpp tvgSwImage.cpp tvgSwMath.cpp tvgSwMemPool.cpp tvgSwRaster.cpp tvgSwRasterAvx.h tvgSwRasterC.h tvgSwRasterNeon.h tvgSwRasterTexmap.h tvgSwRenderer.cpp tvgSwRenderer.h tvgSwRle.cpp tvgSwShape.cpp tvgSwStroke.cpp tvgTaskScheduler.cpp tvgTaskScheduler.h tvgText.cpp tvgText.h tvgWgCanvas.cpp tvgXmlParser.cpp tvgXmlParser.h
    ../Middlewares/LVGL/GUI/lvgl/src/libs/thorvg/rapidjson/: allocators.h cursorstreamwrapper.h document.h encodedstream.h encodings.h filereadstream.h filewritestream.h fwd.h istreamwrapper.h memorybuffer.h memorystream.h ostreamwrapper.h pointer.h prettywriter.h rapidjson.h reader.h schema.h stream.h stringbuffer.h uri.h writer.h
    ../Middlewares/LVGL/GUI/lvgl/src/libs/thorvg/rapidjson/msinttypes/: inttypes.h stdint.h
    ../Middlewares/LVGL/GUI/lvgl/src/libs/thorvg/rapidjson/internal/: biginteger.h clzll.h diyfp.h dtoa.h ieee754.h itoa.h meta.h pow10.h regex.h stack.h strfunc.h strtod.h swap.h
    ../Middlewares/LVGL/GUI/lvgl/src/libs/thorvg/rapidjson/error/: en.h error.h
    ../Middlewares/LVGL/GUI/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c lv_tiny_ttf.h stb_rect_pack.h stb_truetype_htcw.h
    ../Middlewares/LVGL/GUI/lvgl/src/libs/tjpgd/: lv_tjpgd.c lv_tjpgd.h tjpgd.c tjpgd.h tjpgdcnf.h
  group MiddleWare/lvgl/src/tick
    ../Middlewares/LVGL/GUI/lvgl/src/tick/: lv_tick.c lv_tick.h lv_tick_private.h
  group MiddleWare/lvgl/src/osal
    ../Middlewares/LVGL/GUI/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_windows.c
  group MiddleWare/lvgl/src/others
    ../Middlewares/LVGL/GUI/lvgl/src/others/file_explorer/: lv_file_explorer.c lv_file_explorer.h lv_file_explorer_private.h
    ../Middlewares/LVGL/GUI/lvgl/src/others/font_manager/: lv_font_manager.c lv_font_manager.h lv_font_manager_recycle.c lv_font_manager_recycle.h lv_font_manager_utils.c lv_font_manager_utils.h
    ../Middlewares/LVGL/GUI/lvgl/src/others/fragment/: lv_fragment.c lv_fragment.h lv_fragment_manager.c lv_fragment_private.h
    ../Middlewares/LVGL/GUI/lvgl/src/others/gridnav/: lv_gridnav.c lv_gridnav.h
    ../Middlewares/LVGL/GUI/lvgl/src/others/ime/: lv_ime_pinyin.c lv_ime_pinyin.h lv_ime_pinyin_private.h
    ../Middlewares/LVGL/GUI/lvgl/src/others/imgfont/: lv_imgfont.c lv_imgfont.h
    ../Middlewares/LVGL/GUI/lvgl/src/others/monkey/: lv_monkey.c lv_monkey.h lv_monkey_private.h
    ../Middlewares/LVGL/GUI/lvgl/src/others/observer/: lv_observer.c lv_observer.h lv_observer_private.h
    ../Middlewares/LVGL/GUI/lvgl/src/others/snapshot/: lv_snapshot.c lv_snapshot.h
    ../Middlewares/LVGL/GUI/lvgl/src/others/sysmon/: lv_sysmon.c lv_sysmon.h lv_sysmon_private.h
    ../Middlewares/LVGL/GUI/lvgl/src/others/vg_lite_tvg/: vg_lite.h vg_lite_matrix.c vg_lite_tvg.cpp
  group MiddleWare/lvgl/src/stdlib
    ../Middlewares/LVGL/GUI/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c lv_tlsf.h lv_tlsf_private.h
    ../Middlewares/LVGL/GUI/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../Middlewares/LVGL/GUI/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../Middlewares/LVGL/GUI/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../Middlewares/LVGL/GUI/lvgl/src/stdlib/: lv_mem.c lv_mem.h lv_mem_private.h lv_sprintf.h lv_string.h
  group MiddleWare/lvgl/src/themes
    ../Middlewares/LVGL/GUI/lvgl/src/themes/default/: lv_theme_default.c lv_theme_default.h
    ../Middlewares/LVGL/GUI/lvgl/src/themes/mono/: lv_theme_mono.c lv_theme_mono.h
    ../Middlewares/LVGL/GUI/lvgl/src/themes/simple/: lv_theme_simple.c lv_theme_simple.h
    ../Middlewares/LVGL/GUI/lvgl/src/themes/: lv_theme.c lv_theme.h lv_theme_private.h
  group MiddleWare/lvgl/src/indev
    ../Middlewares/LVGL/GUI/lvgl/src/indev/: lv_indev.c lv_indev.h lv_indev_private.h lv_indev_scroll.c lv_indev_scroll.h
